Commit message: reward fix

File: humanoid3_colli.urdf (robot description, URDF)
Before this commit: robot simple_humanoid, 31 links, 30 joints
Joints:
- joint RARM_SHOULDER_R: axis 1 0 0 -> -1 0 0
